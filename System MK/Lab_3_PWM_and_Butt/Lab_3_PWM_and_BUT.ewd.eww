<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Lab_3_PWM_and_BUT.ewp</path>
  </project>
  <batchBuild/>
</workspace>


