<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Lab2_Dig_IO_And_Timer.ewp</path>
  </project>
  <batchBuild/>
</workspace>


